# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\Common; ..\..\..\..\Drivers\BSP\CX32L003_StarterKit; ..\..\..\..\Drivers\CMSIS\Device\XMC\CX32L003\Include; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CX32L003_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\XMC\cx32f003f8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Common; ..\..\..\..\Drivers\BSP\CX32L003_StarterKit; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\XMC\CX32L003\Include; ..\..\..\..\Drivers\CX32L003_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.hex
  group Application/ARM
    ../../../../Drivers/CMSIS/Device/XMC/CX32L003/Source/IAR/: startup_cx32l003.s
  group Application/User
    ../Src/: cx32l003_hal_msp.c cx32l003_it.c main.c
  group Common
    ../../../../Common/: log.c util.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/CX32L003_HAL_StarterKit
    ../../../../Drivers/BSP/CX32L003_StarterKit/: cx32l003_starterkit.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/XMC/CX32L003/Source/: system_cx32l003.c
  group Drivers/CX32L003_HAL_Driver
    ../../../../Drivers/CX32L003_HAL_Driver/Src/: cx32l003_hal.c cx32l003_hal_adc.c cx32l003_hal_awk.c cx32l003_hal_basetim.c cx32l003_hal_beep.c cx32l003_hal_clktrim.c cx32l003_hal_cortex.c cx32l003_hal_crc.c cx32l003_hal_flash.c cx32l003_hal_gpio.c cx32l003_hal_i2c.c cx32l003_hal_iwdg.c cx32l003_hal_lptim.c cx32l003_hal_lpuart.c cx32l003_hal_lvd.c cx32l003_hal_owire.c cx32l003_hal_pca.c cx32l003_hal_pwr.c cx32l003_hal_rcc.c cx32l003_hal_rtc.c cx32l003_hal_spi.c cx32l003_hal_tim.c cx32l003_hal_uart.c cx32l003_hal_vc.c cx32l003_hal_wwdg.c
