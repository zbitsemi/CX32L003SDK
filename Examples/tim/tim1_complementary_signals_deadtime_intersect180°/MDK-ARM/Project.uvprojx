# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CX32L003F8 XMC
  pack: XMC.CX32L003_DFP.1.0.7
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Common;../../../../Drivers/CX32L003_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/XMC/CX32L003/Include;../../../../Drivers/BSP/CX32L003_StarterKit
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/BSP/CX32L003_StarterKit
    ../../../../Drivers/BSP/CX32L003_StarterKit/: cx32l003_starterkit.c
  group Drivers/CX32L0xx_HAL_Driver
    ../../../../Drivers/CX32L003_HAL_Driver/Src/: cx32l003_hal.c cx32l003_hal_rcc.c cx32l003_hal_adc.c cx32l003_hal_cortex.c cx32l003_hal_crc.c cx32l003_hal_flash.c cx32l003_hal_gpio.c cx32l003_hal_iwdg.c cx32l003_hal_wwdg.c cx32l003_hal_tim.c cx32l003_hal_basetim.c cx32l003_hal_lptim.c cx32l003_hal_lvd.c cx32l003_hal_beep.c cx32l003_hal_pwr.c cx32l003_hal_awk.c cx32l003_hal_spi.c cx32l003_hal_vc.c cx32l003_hal_uart.c cx32l003_hal_lpuart.c cx32l003_hal_clktrim.c cx32l003_hal_i2c.c cx32l003_hal_rtc.c cx32l003_hal_pca.c cx32l003_hal_owire.c
  group Application/MDK-ARM
    ../../../../Drivers/CMSIS/Device/XMC/CX32L003/Source/ARM/: startup_cx32l003.s
  group Application/User
    ../Src/: main.c cx32l003_hal_msp.c cx32l003_it.c
  group Drivers/CMSIS
    ../../../../Drivers/CMSIS/Device/XMC/CX32L003/Source/: system_cx32l003.c
  group Common
    ../../../../Common/: log.c util.c
  group Doc
    ../: readme.txt
